# Keil uVision project project_dma.uvprojx, settings and files
target workspace (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Lesson1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\workspace;.\CMSIS\inc;.\Code\inc;.\FreeRTOS\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ./Startup/: startup_stm32f429xx.s
  group CMSIS
    ./CMSIS/src/: system_stm32f4xx.c
  group Code
    ./Code/src/: main.c sysinit.c TimLib.c UartLib.c AdcLib.c DacLib.c DmaLib.c
  group FreeRTOS
    ./FreeRTOS/src/: croutine.c event_groups.c list.c port.c queue.c stream_buffer.c tasks.c timers.c heap_1.c
